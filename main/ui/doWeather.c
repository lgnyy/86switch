#include <stdio.h>
#include <stdlib.h>
#include <string.h>
#include "yos_nvs.h"
#include "yos_http.h"
#include "cJSON.h"
#include "zlib.h"
#include "doWeather.h"


const char* config_keys[] = { "city_pos", "api_key", NULL };
static const char* weatcher_display_items[] = {"text", "temp", "windScale", "humidity", NULL};
static const char* weatcher_ca_cert = "\x30\x82\x05\x8A\x30\x82\x03\x72\xA0\x03\x02\x01\x02\x02\x10\x75\x8D\xFD\x8B\xAE\x7C\x07\x00\xFA\xA9\x25\xA7\xE1\xC7\xAD\x14\x30\x0D\x06\x09\x2A\x86\x48\x86\xF7\x0D\x01\x01\x0C\x05\x00\x30\x5F\x31\x0B\x30\x09\x06\x03\x55\x04\x06\x13\x02\x47\x42\x31\x18\x30\x16\x06\x03\x55\x04\x0A\x13\x0F\x53\x65\x63\x74\x69\x67\x6F\x20\x4C\x69\x6D\x69\x74\x65\x64\x31\x36\x30\x34\x06\x03\x55\x04\x03\x13\x2D\x53\x65\x63\x74\x69\x67\x6F\x20\x50\x75\x62\x6C\x69\x63\x20\x53\x65\x72\x76\x65\x72\x20\x41\x75\x74\x68\x65\x6E\x74\x69\x63\x61\x74\x69\x6F\x6E\x20\x52\x6F\x6F\x74\x20\x52\x34\x36\x30\x1E\x17\x0D\x32\x31\x30\x33\x32\x32\x30\x30\x30\x30\x30\x30\x5A\x17\x0D\x34\x36\x30\x33\x32\x31\x32\x33\x35\x39\x35\x39\x5A\x30\x5F\x31\x0B\x30\x09\x06\x03\x55\x04\x06\x13\x02\x47\x42\x31\x18\x30\x16\x06\x03\x55\x04\x0A\x13\x0F\x53\x65\x63\x74\x69\x67\x6F\x20\x4C\x69\x6D\x69\x74\x65\x64\x31\x36\x30\x34\x06\x03\x55\x04\x03\x13\x2D\x53\x65\x63\x74\x69\x67\x6F\x20\x50\x75\x62\x6C\x69\x63\x20\x53\x65\x72\x76\x65\x72\x20\x41\x75\x74\x68\x65\x6E\x74\x69\x63\x61\x74\x69\x6F\x6E\x20\x52\x6F\x6F\x74\x20\x52\x34\x36\x30\x82\x02\x22\x30\x0D\x06\x09\x2A\x86\x48\x86\xF7\x0D\x01\x01\x01\x05\x00\x03\x82\x02\x0F\x00\x30\x82\x02\x0A\x02\x82\x02\x01\x00\x93\xBE\xD5\x36\x52\x75\xD8\x01\x23\xA0\x1C\x47\x42\x49\xEE\x63\xB6\xB7\x21\xFD\xC4\x95\xD5\x48\x2B\x26\x7C\x14\x53\x10\xDA\x79\xFD\x2B\xB7\x2D\xA4\xD4\x2C\xFA\xEA\x32\xDD\x49\xC2\xB9\xBD\x0F\x48\x3D\x7B\x5A\x98\x54\xAF\x9E\x5D\x31\x74\x4F\x07\xFC\x50\x21\xDD\xA4\xCF\x68\x4F\x1B\x12\x63\x6D\x25\x99\x4C\x2A\x99\xF3\x48\x30\x61\xFA\x81\x7C\x1E\xA7\x08\x4A\xDC\x3E\x2B\x1C\x1F\x18\x4C\x71\xAA\x35\x8C\xAD\xF8\x6E\xE8\x3B\x4A\xD9\xE5\x94\x02\xD6\x89\x84\x13\xAA\x6D\xC8\x4F\x33\xCC\x50\x96\x37\x92\x33\xDC\x5F\x88\xE7\x9F\x54\xD9\x48\xF0\x98\x43\xD6\x66\xFD\x9F\x17\x38\x43\xC5\x01\x51\x0B\xD7\xE3\x23\x0F\x14\x5D\x5B\x14\xE7\x4B\xBE\xDD\xF4\xC8\xDA\x03\x37\xD1\xD6\x39\xA1\x21\x51\x30\x83\xB0\x6D\xD7\x30\x4E\x96\x5B\x91\xF0\x70\x24\xAB\xBF\x45\x81\x64\x43\x0D\xBD\x21\x3A\x2F\x3C\xE9\x9E\x0D\xCB\x20\xB5\x42\x27\xCC\xDA\x6F\x9B\xEE\x64\x30\x90\x39\xCD\x93\x65\x81\x21\x31\xB5\x23\x50\x33\x37\x22\xE3\x38\xED\xF8\x31\x30\xCC\x45\xFE\x62\xF9\xD1\x5D\x32\x79\x42\x87\xDF\x6A\xCC\x56\x19\x40\x4D\xCE\xAA\xBB\xF9\xB5\x76\x49\x94\xF1\x27\xF8\x91\xA5\x83\xE5\x06\xB3\x63\x0E\x80\xDC\xE0\x12\x55\x80\xA6\x3B\x66\xB4\x39\x87\x2D\xC8\xF0\xD0\xD1\x14\xE9\xE4\x0D\x4D\x0E\xF6\x5D\x57\x72\xC5\x3B\x1C\x47\x56\x9D\xE2\xD5\xFB\x81\x61\x8C\xCC\x4D\x80\x90\x34\x5B\xB7\xD7\x14\x75\xDC\xD8\x04\x48\x9F\xC0\xC1\x28\x88\xB4\xE9\x1C\xCA\xA7\xB1\xF1\x56\xB7\x7B\x49\x4C\x59\xE5\x20\x15\xA8\x84\x02\x29\xFA\x38\x94\x69\x9A\x49\x06\x8F\xCD\x1F\x79\x14\x17\x12\x0C\x83\x7A\xDE\x1F\xB1\x97\xEE\xF9\x97\x78\x28\xA4\xC8\x44\x92\xE9\x7D\x26\x05\xA6\x58\x72\x9B\x79\x13\xD8\x11\x5F\xAE\xC5\x38\x62\x34\x68\xB2\x86\x30\x8E\xF8\x90\x61\x9E\x32\x6C\xF5\x07\x36\xCD\xA2\x4C\x6E\xEC\x8A\x36\xED\xF2\xE6\x99\x15\x44\x70\xC3\x7C\xBC\x9C\x39\xC0\xB4\xE1\x6B\xF7\x83\x25\x23\x57\xD9\x12\x80\xE5\x49\xF0\x75\x0F\xEF\x8D\xEB\x1C\x9B\x54\x28\xB4\x21\x3C\xFC\x7C\x0A\xFF\xEF\x7B\x6B\x75\xFF\x8B\x1D\xA0\x19\x05\xAB\xFA\xF8\x2B\x81\x42\xE8\x38\xBA\xBB\xFB\xAA\xFD\x3D\xE0\xF3\xCA\xDF\x4E\x97\x97\x29\xED\xF3\x18\x56\xE9\xA5\x96\xAC\xBD\xC3\x90\x98\xB2\xE0\xF9\xA2\xD4\xA6\x47\x43\x7C\x6D\xCF\x02\x03\x01\x00\x01\xA3\x42\x30\x40\x30\x1D\x06\x03\x55\x1D\x0E\x04\x16\x04\x14\x56\x73\x58\x64\x95\xF9\x92\x1A\xB0\x12\x2A\x04\x62\x79\xA1\x40\x15\x88\x21\x49\x30\x0E\x06\x03\x55\x1D\x0F\x01\x01\xFF\x04\x04\x03\x02\x01\x86\x30\x0F\x06\x03\x55\x1D\x13\x01\x01\xFF\x04\x05\x30\x03\x01\x01\xFF\x30\x0D\x06\x09\x2A\x86\x48\x86\xF7\x0D\x01\x01\x0C\x05\x00\x03\x82\x02\x01\x00\x2F\x5C\x99\x3C\xFC\x06\x5E\x8C\x94\x2E\x70\xEA\xD2\x32\x31\x8D\xB4\xF0\x51\xD5\xBC\x0A\xF3\x64\x9F\x07\x5E\xD5\xC1\x73\x68\x64\x7A\xA2\xB9\x0E\xE8\xF9\x5D\x85\x2D\xA8\x37\x45\xAA\x28\xF4\x96\x05\x50\x60\xA9\x49\x7E\x9F\xE2\x99\x36\x29\x13\x44\x47\x6A\x9D\x55\x20\x3C\xD8\x9B\xF1\x03\x32\xBA\xDA\x40\xA1\x73\xEA\x83\xA1\xB7\x44\xA6\x0E\x99\x01\x9B\xE4\xBC\x7F\xBE\x13\x94\x7E\xCA\xA6\x1E\x76\x80\x36\x3D\x84\x06\x8B\x33\x26\x65\x6D\xCA\x7E\x9E\xFE\x1F\x8C\x58\x38\x7B\x1A\x83\xB1\x0F\xBC\x17\x11\xBB\xE6\x06\xCC\x63\xFA\x81\xF2\x81\x4C\xDA\x0B\x10\x6B\xA1\xFA\xD5\x28\xA5\xCF\x06\x40\x16\xFF\x7B\x7D\x18\x5E\x39\x12\xA4\x53\x9E\x7E\x32\x42\x10\xA6\x21\x91\xA9\x1C\x4E\x17\x7C\x84\xBC\x9F\x8C\xD1\xE8\xDF\xE6\x51\xB9\x36\x47\x3F\x90\xB9\xC7\xBC\x02\xDC\x5B\x1C\x4F\x0E\x48\xC1\x25\x83\x9C\x0A\x3F\x9E\xB1\x03\x33\x12\x1A\x27\xAC\xF7\x22\x6C\x24\xD1\x01\x41\xF8\x58\x03\xFE\x25\x68\x22\x1F\x9A\x5A\x3C\x7C\x6C\x9E\x75\x48\xF3\x81\xF1\x66\x67\x6E\x4C\x82\xC0\xEE\xBA\x57\x0E\x18\xEF\x2E\x9A\xF7\x12\xD8\xA0\x6B\xE9\x05\xA5\xA1\xE9\x68\xF8\xBC\x4C\x3F\x12\x1E\x45\xE8\x52\xC0\xA3\xBF\x12\x27\x79\xB9\xCC\x31\x3C\xC3\xF6\x3A\x22\x16\x03\xA0\xC9\x8F\x66\xA4\x5B\xA2\x4D\xD6\x81\x25\x06\xE9\x76\xA4\x00\x0A\x3E\xCB\xCD\x35\x9B\xE0\xE1\x38\xCB\x60\x53\x86\x28\x42\x41\x1C\x44\x57\xE8\xA8\xAD\xAB\x45\xE3\x25\x10\xBC\xDB\x3E\x65\x41\xFB\x1B\xA6\x97\x0F\xEB\xB9\x74\x79\xF9\x1E\xBC\x1D\x57\x0D\x47\xAF\xC3\x2F\x9F\x87\x46\xA7\xEB\x26\x5A\x0F\x56\x63\xB5\x62\x60\x6E\x00\xFB\xE3\x27\x11\x22\xE7\xFE\x99\x8F\x34\xF5\xB9\xE8\xC3\x91\x72\xBD\xD8\xC3\x1E\xB9\x2E\xF2\x91\x44\x51\xD0\x57\xCD\x0C\x34\xD5\x48\x21\xBF\xDB\x13\xF1\x66\x25\x43\x52\xD2\x70\x22\x36\xCD\x9F\xC4\x1C\x75\x20\xAD\x63\x72\x63\x06\x0F\x0E\x27\xCE\xD2\x6A\x0D\xBC\xB5\x39\x1A\xE9\xD1\x76\x7A\xD1\x5C\xE4\xE7\x49\x49\x2D\x55\x37\x68\xF0\x1A\x3A\x98\x3E\x54\x17\x87\x54\xE9\xA6\x27\x50\x89\x7B\x20\x2F\x3F\xFF\xBF\xA1\x8B\x4A\x47\x98\xFF\x2B\x7B\x49\x3E\xC3\x29\x46\x60\x18\x42\xAB\x33\x29\xBA\xC0\x29\xB9\x13\x89\xD3\x88\x8A\x39\x41\x3B\xC9\xFD\xA6\xED\x1F\xF4\x60\x63\xDF\xD2\x2D\x55\x01\x8B";
static int ungzip(char* src, int src_len, char* des, int des_len);
static int json_parse_display(const char* str, weather_display_cb_t display_cb, void* arg);
static int weather_load_config(void* ctx, yos_nvs_read_cb_t read_cb, void* arg);
static int weather_save_config(void* ctx, yos_nvs_write_cb_t write_cb, void* arg);
static int weather_query_internal(const char* city_pos, const char* api_key, weather_display_cb_t display_cb, void* arg);


const char** weather_get_config_keys(void)
{
    return config_keys;
}

static int weather_get_pos_key(char pos[64], char key[64])
{
    char* args[2] = { pos, key };
    int ret = yos_nvs_load(YOS_NVS_WEATHER_INFO_NAMESPACE, weather_load_config, args);
    if (ret != 0) {
        strcpy(pos, "116.39145,39.9073"); // BEIJING
        strcpy(key, "c98d7cb82cdc49b7a20f8367e865868a"); // github
        //return ret;
    }
    return 0;
}

int weather_load_config_semicolon(char* pos_key, int max_len) 
{
    char key[64] = { 0 };
    weather_get_pos_key(pos_key, key);
    strncat(pos_key, ";", max_len);
    strncat(pos_key, key, max_len);
    return 0;
}

int weather_save_config_semicolon(const char* pos_key, int len)
{
    char pos[64] = { 0 }, key[64] = { 0 };
    int i;
    for (i = 0; (i < len) && (pos_key[i] != ';'); i++);
    if ((i < len) && ((i < (int)sizeof(pos)) && ((len - i - 1) < (int)sizeof(key)))) {
        memcpy(pos, pos_key, i);
        memcpy(key, pos_key+1, len);

        return weather_query_first(pos, key, NULL, NULL);
    }
    return -1;
}

int weather_query_first(const char* pos, const char* key, weather_display_cb_t display_cb, void* arg)
{
    int ret = weather_query_internal(pos, key, display_cb, arg);
    if (ret == 0) {
        const char* args[2] = { pos , key };
        ret = yos_nvs_save(YOS_NVS_WEATHER_INFO_NAMESPACE, weather_save_config, (void*)args);
    }
    return ret;
}

int weather_query(weather_display_cb_t display_cb, void* arg)
{
    char pos[64] = { 0 }, key[64] = { 0 };
    weather_get_pos_key(pos, key);
    return weather_query_internal(pos, key, display_cb, arg);
}


// 解压函数
static int ungzip(char* src, int src_len, char* des, int des_len) {
    z_stream d_stream = { 0 };

    // 初始化解压流
    int ret = inflateInit2(&d_stream, 47);
    if (ret != Z_OK) {
        des[0] = '\0';
        return 0;
    }

    d_stream.next_in = (z_const Bytef*)src;
    d_stream.avail_in = src_len;
    d_stream.next_out = (Bytef*)des;
    d_stream.avail_out = des_len;

    // 解压数据
    int offset = 0;
    ret = inflate(&d_stream, Z_NO_FLUSH);
    if ((ret == Z_STREAM_END) && (d_stream.avail_out > 0)) {
        offset = des_len - d_stream.avail_out;
    }
    des[offset] = '\0';

    // 清理解压流
    (void)inflateEnd(&d_stream);
    return offset;
}

static int json_parse_display(const char* str, weather_display_cb_t display_cb, void* arg) {
    cJSON* root = cJSON_Parse(str);
    if (root == NULL) {
        return -1;
    }

    int ret = 0;
    char* code = cJSON_GetStringValue(cJSON_GetObjectItemCaseSensitive(root, "code"));
    if ((code == NULL) || (strcmp(code, "200") != 0)) {
        printf("weather_query json_parse_display str:%s\n", str);
        ret = -1;
        goto end;
    }
   
    cJSON* now_json = cJSON_GetObjectItemCaseSensitive(root, "now");
    if (now_json == NULL) {
        goto end;
    }

    if (display_cb != NULL) {
        int i;
        for (i = 0; weatcher_display_items[i]; i++) {
            char* value = cJSON_GetStringValue(cJSON_GetObjectItemCaseSensitive(now_json, weatcher_display_items[i]));

            display_cb(arg, i, value);
        }
    }
 
end:
    cJSON_Delete(root);
    return ret;
}

static int weather_load_config(void* ctx, yos_nvs_read_cb_t read_cb, void* arg) {
    char** args = (char**)ctx;
    int ret = read_cb(arg, config_keys[0], args[0], 64);
    if (ret == 0){
        ret = read_cb(arg, config_keys[1], args[1], 64);
    }
    return ret;
}

static int weather_save_config(void* ctx, yos_nvs_write_cb_t write_cb, void* arg) {
    const char** args = (const char**)ctx;
    int ret = write_cb(arg, config_keys[0], args[0]);
    if (ret == 0) {
        ret = write_cb(arg, config_keys[1], args[1]);
    }
    return ret;
}


static int weather_query_internal(const char* city_pos, const char* api_key, weather_display_cb_t display_cb, void* arg)
{
    char url[256];
    snprintf(url, sizeof(url), "https://devapi.qweather.com/v7/weather/now?location=%s&key=%s&lang=cn", city_pos, api_key);
 
    // 联机查询天气预报
    uint8_t* resp = NULL;
    uint32_t resp_len = 0;
    int32_t ret = yos_http_static_request(url, weatcher_ca_cert, NULL, NULL, 0, &resp, &resp_len);
    if (ret != 0) {
        return ret;
    }

    // 调用解压函数
    int des_len = resp_len * 4 + 256;
    char* des = (char* )malloc(des_len);
    if (des != NULL) {
        ungzip((char*)resp, (int)resp_len, des, des_len);

        //printf("weather_query resp_len:%ld, des_len:%d, strlen:%d\n", resp_len, des_len, (int)strlen(des));
        
        ret = json_parse_display(des, display_cb, arg);
    }
    else {
        ret = -2;
    }
 
    yos_http_static_free(resp);
    free(des);
    return ret;
}
